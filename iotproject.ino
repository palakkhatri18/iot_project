#include <LedControl.h>

#define DIN 7   
#define CS  5   
#define CLK 6   

LedControl matrix = LedControl(DIN, CLK, CS, 1);

// Font definitions for A-Z (8x8 pixel representation)
const byte font[][8] = {
  {0x18, 0x24, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42}, // A
  {0x7C, 0x42, 0x42, 0x7C, 0x42, 0x42, 0x7C, 0x00}, // B
  {0x3C, 0x42, 0x40, 0x40, 0x40, 0x42, 0x3C, 0x00}, // C
  {0x78, 0x44, 0x42, 0x42, 0x42, 0x44, 0x78, 0x00}, // D
  {0x7E, 0x40, 0x40, 0x7C, 0x40, 0x40, 0x7E, 0x00}, // E
  {0x7E, 0x40, 0x40, 0x7C, 0x40, 0x40, 0x40, 0x00}, // F
  {0x3C, 0x42, 0x40, 0x4E, 0x42, 0x42, 0x3C, 0x00}, // G
  {0x42, 0x42, 0x42, 0x7E, 0x42, 0x42, 0x42, 0x00}, // H
  {0x7E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E, 0x00}, // I
  {0x0E, 0x04, 0x04, 0x04, 0x44, 0x44, 0x38, 0x00}, // J
  {0x42, 0x44, 0x48, 0x50, 0x48, 0x44, 0x42, 0x00}, // K
  {0x40, 0x40, 0x40, 0x40, 0x40, 0x40, 0x7E, 0x00}, // L
  {0x42, 0x66, 0x5A, 0x42, 0x42, 0x42, 0x42, 0x00}, // M
  {0x42, 0x62, 0x52, 0x4A, 0x46, 0x42, 0x42, 0x00}, // N
  {0x3C, 0x42, 0x42, 0x42, 0x42, 0x42, 0x3C, 0x00}, // O
  {0x7C, 0x42, 0x42, 0x7C, 0x40, 0x40, 0x40, 0x00}, // P
  {0x3C, 0x42, 0x42, 0x42, 0x46, 0x42, 0x3D, 0x00}, // Q
  {0x7C, 0x42, 0x42, 0x7C, 0x48, 0x44, 0x42, 0x00}, // R
  {0x3C, 0x42, 0x40, 0x3C, 0x02, 0x42, 0x3C, 0x00}, // S
  {0x7E, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00}, // T
  {0x42, 0x42, 0x42, 0x42, 0x42, 0x42, 0x3C, 0x00}, // U
  {0x42, 0x42, 0x42, 0x42, 0x24, 0x18, 0x18, 0x00}, // V
  {0x42, 0x42, 0x42, 0x42, 0x5A, 0x66, 0x42, 0x00}, // W
  {0x42, 0x42, 0x24, 0x18, 0x18, 0x24, 0x42, 0x00}, // X
  {0x42, 0x42, 0x24, 0x18, 0x18, 0x18, 0x18, 0x00}, // Y
  {0x7E, 0x02, 0x04, 0x18, 0x20, 0x40, 0x7E, 0x00}, // Z
  {0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00}  // Space
};

const char message[] = "POOKIES ";  // Your input text (add space at end)
const int messageLength = sizeof(message) - 1;

void scrollText() {
  while (true) {  // Infinite loop
    for (int charIndex = 0; charIndex < messageLength; charIndex++) {
      int letterIndex = message[charIndex] - 'A';

      if (message[charIndex] == ' ') {
        letterIndex = 26; // Space character
      }

      if (letterIndex >= 0 && letterIndex <= 26) { // If valid letter
        for (int shift = 0; shift < 8; shift++) {
          matrix.clearDisplay(0);
          for (int i = 0; i < 8; i++) {
            matrix.setRow(0, i, font[letterIndex][i] >> shift);
          }
          delay(150);  // Adjust speed of scrolling
        }
      }
    }
  }
}

void setup() {
  matrix.shutdown(0, false);
  matrix.setIntensity(0, 8);
  matrix.clearDisplay(0);
}

void loop() {
  scrollText();  // Runs infinitely
}
